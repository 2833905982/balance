# Keil uVision project BH-F103.uvprojx, settings and files
target Balance (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\Libraries\FWlib;..\..\Mpu6050;..\..\Mpu6050\Mpu6050;..\..\User\Delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Key/: key.c
    ../../User/Usart3/: usart3.c
    ../../User/Usart1/: bsp_usart1.c
    ../../User/Oled/: oled.c
    ../../User/Delay/: delay.c
    ../../User/GeneralTim3/: GeneralTim3.c
    ../../User/PWM/: PWM.c
    ../../User/Encoder/: encoder.c
    ../../User/GpioOut/: gpioout.c
    ../../User/Contral/: contral.c
    ../../User/Motor/: motor.c
  group DOC
    ../../Doc/: readme.txt
  group MPU6050
    ../../Mpu6050/Mpu6050/: mpu6050.c
    ../../Mpu6050/Mpuiic/: mpuiic.c
    ../../Mpu6050/Dmp/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../../Mpu6050/Exti/: exti.c
